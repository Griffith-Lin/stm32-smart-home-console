# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\user;..\user\api;..\startup;..\lib\inc;..\user\ff14b\source;..\user\ASR_MIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c main.h stm32f4xx_it.c system_stm32f4xx.c
  group api
    ../user/api/: LED.c usart1.c key.c debug.c sg90.c beep.c tim.c delay.c motor.c adc.c gl5506.c pd333b.c w25qxx.c spi.c bitband.h ws2812e.c i2c.c MLX90614.c rtc.c infrared.c SHT30.c lcd.c tc_iic.c sys.c dma.c dma.h sd_driver.c sd_driver.h hlk_v20.c esp-12f.c esp-12f.h relay.c relay.h font1.c font1.h
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group lib
    ../lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group fatfs
    ../user/ff14b/source/: diskio.c ff.c ffsystem.c ffunicode.c exfuns.c
  group asr_mimc
    ../user/ASR_MIC/: audioplay.c i2s.c mymalloc.c revert.c wavplay.c wm8978.c wmiic.c
software components: CMSIS:CORE 5.5.0
